# Repository Kiogora/narra (continued)

## KiCad design hardware/Bitsoko-ESP32-module/Bitsoko-ESP32-module.kicad_pcb (continued)

Parts:
J2: CONN_01X20; Pin_Header_5mil_staggered_1x20_2.54mm

Connections:
/sheet5955264A/IO2: J2.11; also elsewhere on the board
/sheet5955264A/IO4: J2.10; also elsewhere on the board
/sheet5955264A/IO5: J2.7; also elsewhere on the board
/sheet5955264A/IO15: J2.12; also elsewhere on the board
/sheet5955264A/IO16: J2.9; also elsewhere on the board
/sheet5955264A/IO17: J2.8; also elsewhere on the board
/sheet5955264A/IO18: J2.6; also elsewhere on the board
/sheet5955264A/IO19: J2.5; also elsewhere on the board
/sheet5955264A/IO21: J2.4; also elsewhere on the board
/sheet5955264A/IO22: J2.3; also elsewhere on the board
/sheet5955264A/IO23: J2.2; also elsewhere on the board
/sheet5955264A/SD0: J2.18; also elsewhere on the board
/sheet5955264A/SD1: J2.17; also elsewhere on the board
/sheet59552649/EN: J2.16; also elsewhere on the board
/sheet59552649/IO0: J2.15; also elsewhere on the board
/sheet59552649/RX: J2.13; also elsewhere on the board
/sheet59552649/TX: J2.14; also elsewhere on the board
GND: J2.1, J2.19, J2.20; also elsewhere on the board

Parts:
J3: CONN_01X20; Pin_Header_5mil_staggered_1x20_2.54mm

Connections:
3v3: J3.5; also elsewhere on the board
/sheet5955264A/CLK: J3.1; also elsewhere on the board
/sheet5955264A/CMD: J3.2; also elsewhere on the board
/sheet5955264A/IO12: J3.10; also elsewhere on the board
/sheet5955264A/IO13: J3.9; also elsewhere on the board
/sheet5955264A/IO14: J3.11; also elsewhere on the board
/sheet5955264A/IO25: J3.14; also elsewhere on the board
/sheet5955264A/IO26: J3.13; also elsewhere on the board
/sheet5955264A/IO27: J3.12; also elsewhere on the board
/sheet5955264A/IO32: J3.16; also elsewhere on the board
/sheet5955264A/IO33: J3.15; also elsewhere on the board
/sheet5955264A/IO34: J3.18; also elsewhere on the board
/sheet5955264A/IO35: J3.17; also elsewhere on the board
/sheet5955264A/SD2: J3.4; also elsewhere on the board
/sheet5955264A/SD3: J3.3; also elsewhere on the board
/sheet5955264A/SENSOR_VN: J3.19; also elsewhere on the board
/sheet5955264A/SENSOR_VP: J3.20; also elsewhere on the board
/sheet59552648/EXT_5V: J3.7; also elsewhere on the board

Board: 2 copper layers, 39.4 x 53.3 mm, 16 parts (2 on the bottom side), 37 nets.

## KiCad design drivers/ND-01/ND-01.kicad_pcb

Board: 4 copper layers, 232.4 x 49.5 mm, 76 parts (8 on the bottom side), 158 nets.

Parts:
C1: 1000uF; CP_Radial_D5.0mm_P2.50mm
C2: 0.1uF; CP_Radial_D5.0mm_P2.50mm
C3: 10uF; CP_Radial_D5.0mm_P2.50mm
C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17: C; C_Disc_D3.4mm_W2.1mm_P2.50mm
D1: D_Zener; D_A-405_P10.16mm_Horizontal
D2: LED; LED_D5.0mm
J1: CONN_01X02; Banana_Jack_2Pin
J2: HIROSE-USB-MICROB; Hirose_ZX62D_B_5PA830
J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16: CONN_01X08; Molex_KK-6410-08_08x2.54mm_Straight
J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31, J32, J33, J34, J35, J36, J37, J38, J39: GS2
J40, J41: GS3
M1: MATRIX; Dot_matrix_CC_2088-AS
R1: R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
U1: ULN2803A; DIP-18_W7.62mm_LongPads
U2: 4017; DIP-16_W7.62mm_LongPads
U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14: 74HC595; DIP-16_W7.62mm_LongPads

Connections:
/ND01 MCU INTERFACE/COL-DATA: J3.4, U6.14
/ND01 MCU INTERFACE/COL-RCK: J3.6, U3.12, U4.12, U5.12, U6.12, U7.12, U8.12, U9.12, U10.12, U11.12, U12.12, U13.12, U14.12
/ND01 MCU INTERFACE/COL-SRCLK: J3.5, U3.11, U4.11, U5.11, U6.11, U7.11, U8.11, U9.11, U10.11, U11.11, U12.11, U13.11, U14.11
/ND01 control/C0: J5.1, M1.c0, U6.15
/ND01 control/C1: J5.2, M1.c1, U6.1
/ND01 control/C2: J5.3, M1.c2, U6.2
/ND01 control/C3: J5.4, M1.c3, U6.3
/ND01 control/C4: J5.5, M1.c4, U6.4
/ND01 control/C5: J5.6, M1.c5, U6.5
/ND01 control/C6: J5.7, M1.c6, U6.6
/ND01 control/C7: J5.8, M1.c7, U6.7
/ND01 control/C8: J6.1, M1.c8, U4.15
/ND01 control/C9: J6.2, M1.c9, U4.1
/ND01 control/C10: J6.3, M1.c10, U4.2
/ND01 control/C11: J6.4, M1.c11, U4.3
/ND01 control/C12: J6.5, M1.c12, U4.4
/ND01 control/C13: J6.6, M1.c13, U4.5
/ND01 control/C14: J6.7, M1.c14, U4.6
/ND01 control/C15: J6.8, M1.c15, U4.7
/ND01 control/C16: J7.1, M1.c16, U5.15
/ND01 control/C17: J7.2, M1.c17, U5.1
/ND01 control/C18: J7.3, M1.c18, U5.2
/ND01 control/C19: J7.4, M1.c19, U5.3
/ND01 control/C20: J7.5, M1.c20, U5.4
/ND01 control/C21: J7.6, M1.c21, U5.5
/ND01 control/C22: J7.7, M1.c22, U5.6
/ND01 control/C23: J7.8, M1.c23, U5.7
/ND01 control/C24: J8.1, M1.c24, U3.15
/ND01 control/C25: J8.2, M1.c25, U3.1
/ND01 control/C26: J8.3, M1.c26, U3.2
/ND01 control/C27: J8.4, M1.c27, U3.3
/ND01 control/C28: J8.5, M1.c28, U3.4
/ND01 control/C29: J8.6, M1.c29, U3.5
/ND01 control/C30: J8.7, M1.c30, U3.6
/ND01 control/C31: J8.8, M1.c31, U3.7
/ND01 control/C32: J9.1, U7.15
/ND01 control/C33: J9.2, U7.1
/ND01 control/C34: J9.3, U7.2
/ND01 control/C35: J9.4, U7.3
/ND01 control/C36: J9.5, U7.4
/ND01 control/C37: J9.6, U7.5
/ND01 control/C38: J9.7, U7.6
/ND01 control/C39: J9.8, U7.7
/ND01 control/C40: J10.1, U8.15
/ND01 control/C41: J10.2, U8.1
/ND01 control/C42: J10.3, U8.2
/ND01 control/C43: J10.4, U8.3
/ND01 control/C44: J10.5, U8.4
/ND01 control/C45: J10.6, U8.5
/ND01 control/C46: J10.7, U8.6
/ND01 control/C47: J10.8, U8.7
/ND01 control/C48: J11.1, U9.15
/ND01 control/C49: J11.2, U9.1
/ND01 control/C50: J11.3, U9.2
/ND01 control/C51: J11.4, U9.3
/ND01 control/C52: J11.5, U9.4
/ND01 control/C53: J11.6, U9.5
/ND01 control/C54: J11.7, U9.6
/ND01 control/C55: J11.8, U9.7
/ND01 control/C56: J12.1, U10.15
/ND01 control/C57: J12.2, U10.1
/ND01 control/C58: J12.3, U10.2
/ND01 control/C59: J12.4, U10.3
/ND01 control/C60: J12.5, U10.4
/ND01 control/C61: J12.6, U10.5
/ND01 control/C62: J12.7, U10.6
/ND01 control/C63: J12.8, U10.7
/ND01 control/C64: J13.1, U11.15
/ND01 control/C65: J13.2, U11.1
/ND01 control/C66: J13.3, U11.2
/ND01 control/C67: J13.4, U11.3
/ND01 control/C68: J13.5, U11.4
/ND01 control/C69: J13.6, U11.5
/ND01 control/C70: J13.7, U11.6
/ND01 control/C71: J13.8, U11.7
/ND01 control/C72: J14.1, U12.15
/ND01 control/C73: J14.2, U12.1
/ND01 control/C74: J14.3, U12.2
/ND01 control/C75: J14.4, U12.3
/ND01 control/C76: J14.5, U12.4
/ND01 control/C77: J14.6, U12.5
/ND01 control/C78: J14.7, U12.6
/ND01 control/C79: J14.8, U12.7
/ND01 control/C80: J15.1, U13.15
/ND01 control/C81: J15.2, U13.1
/ND01 control/C82: J15.3, U13.2
/ND01 control/C83: J15.4, U13.3
/ND01 control/C84: J15.5, U13.4
/ND01 control/C85: J15.6, U13.5
/ND01 control/C86: J15.7, U13.6
/ND01 control/C87: J15.8, U13.7
/ND01 control/C88: J16.1, U14.15
/ND01 control/C89: J16.2, U14.1
/ND01 control/C90: J16.3, U14.2
/ND01 control/C91: J16.4, U14.3
/ND01 control/C92: J16.5, U14.4
/ND01 control/C93: J16.6, U14.5
/ND01 control/C94: J16.7, U14.6
/ND01 control/C95: J16.8, U14.7
/ND01 control/LINK-1: U4.14, U6.9
/ND01 control/LINK-2: U4.9, U5.14
/ND01 control/LINK-3: U3.14, U5.9
/ND01 control/LINK-4: U3.9, U7.14
/ND01 control/LINK-5: U7.9, U8.14
/ND01 control/LINK-6: U8.9, U9.14
/ND01 control/LINK-7: U9.9, U10.14
/ND01 control/LINK-8: U10.9, U11.14
/ND01 control/LINK-9: U11.9, U12.14
/ND01 control/LINK-10: U12.9, U13.14
/ND01 control/LINK-11: U13.9, U14.14
/ND01 control/Q0: J40.1, U2.3
/ND01 control/Q1: J39.2, U2.2
/ND01 control/Q2: J38.2, U2.4
/ND01 control/Q3: J37.2, U2.7
/ND01 control/Q4: J36.2, U2.10
/ND01 control/Q5: J35.2, U2.1
/ND01 control/Q6: J34.2, U2.5
/ND01 control/Q7: J33.2, U2.6
/ND01 control/Q8: J40.3, U2.9
/ND01 control/R0: J17.2, J18.2, U1.18
/ND01 control/R1: J19.2, J20.2, U1.17
/ND01 control/R2: J21.2, J22.2, U1.16
/ND01 control/R3: J23.2, J24.2, U1.15
/ND01 control/R4: J25.2, J26.2, U1.14
/ND01 control/R5: J27.2, J28.2, U1.13
/ND01 control/R6: J29.2, J30.2, U1.12
/ND01 control/R7: J31.2, J32.2, U1.11
/ND01 control/ROW-CLK: J3.3, U2.14
/ND01 control/ROW-RST: J3.2, U2.15
/ND01 output/EXT_R0: J4.1, J18.1
/ND01 output/EXT_R1: J4.2, J20.1
/ND01 output/EXT_R2: J4.3, J22.1
/ND01 output/EXT_R3: J4.4, J24.1
/ND01 output/EXT_R4: J4.5, J26.1
/ND01 output/EXT_R5: J4.6, J28.1
/ND01 output/EXT_R6: J4.7, J30.1
/ND01 output/EXT_R7: J4.8, J32.1
/ND01 output/INT_R0: J17.1, M1.r0
/ND01 output/INT_R1: J19.1, M1.r1
/ND01 output/INT_R2: J21.1, M1.r2
/ND01 output/INT_R3: J23.1, M1.r3
/ND01 output/INT_R4: J25.1, M1.r4
/ND01 output/INT_R5: J27.1, M1.r5
/ND01 output/INT_R6: J29.1, M1.r6
/ND01 output/INT_R7: J31.1, M1.r7
/ND01 power/5V: J2.1, J41.3
/ND01 power/TEST: J1.1, J41.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.2, D2.1, J1.2, J2.5, J2.6, J3.7, J3.8, U2.13, U3.8, U3.13, U4.8, U4.13, U5.8, U5.13, U6.8, U6.13, U7.8, U7.13, U8.8, U8.13, U9.8, U9.13, U10.8, U10.13, U11.8, U11.13, U12.8, U12.13, U13.8, U13.13, U14.8, U14.13
unnamed: D2.2, R1.2
unnamed: J33.1, U1.1
unnamed: J34.1, U1.2
unnamed: J35.1, U1.3
unnamed: J36.1, U1.4
unnamed: J37.1, U1.5
unnamed: J38.1, U1.6
unnamed: J39.1, U1.7
unnamed: J40.2, U1.8
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, D1.1, J3.1, J41.2, R1.1, U2.16, U3.10, U3.16, U4.10, U4.16, U5.10, U5.16, U6.10, U6.16, U7.10, U7.16, U8.10, U8.16, U9.10, U9.16, U10.10, U10.16, U11.10, U11.16, U12.10, U12.16, U13.10, U13.16, U14.10, U14.16

## KiCad design narra 5050design/narra 5050design.kicad_pcb

File narra 5050design/README.md:

# narra
An LED Signage Development Project
This is intended to be portable and avail to the user an easy means to fully control the content being displayed. The communication framework is based wireless technology (Bluetooth and Wi-Fi) network that relies fully on local resources to be operational.

Schematic: narra 5050design.sch

Parts:
D1, D2, D3, D4, D5, D6, D7, D8: LED_RGB; LED_5050Series
DH1, DH2: Drill_Hole; MountingHole_2.2mm_M2_ISO7380_Pad
J1, J2: TEST_1P; Measurement_Point_Round-SMD-Pad_Big
L1: BITSOKO_LOGO; bitsoko-logo_smaller
R1, R2, R3, R4, R5, R6, R7, R8: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal

Connections:
/C: D1.4 (BA), D1.5 (GA), D1.6 (RA), D2.4 (BA), D2.5 (GA), D2.6 (RA), D3.4 (BA), D3.5 (GA), D3.6 (RA), D4.4 (BA), D4.5 (GA), D4.6 (RA), D5.4 (BA), D5.5 (GA), D5.6 (RA), D6.4 (BA), D6.5 (GA), D6.6 (RA), D7.4 (BA), D7.5 (GA), D7.6 (RA), D8.4 (BA), D8.5 (GA), D8.6 (RA), J2.1
/R: J1.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2
unnamed: D1.1 (RK), D1.2 (GK), D1.3 (BK), R1.1
unnamed: D2.1 (RK), D2.2 (GK), D2.3 (BK), R2.1
unnamed: D3.1 (RK), D3.2 (GK), D3.3 (BK), R3.1
unnamed: D4.1 (RK), D4.2 (GK), D4.3 (BK), R4.1
unnamed: D5.1 (RK), D5.2 (GK), D5.3 (BK), R5.1
unnamed: D6.1 (RK), D6.2 (GK), D6.3 (BK), R6.1
unnamed: D7.1 (RK), D7.2 (GK), D7.3 (BK), R7.1
unnamed: D8.1 (RK), D8.2 (GK), D8.3 (BK), R8.1

Board: 2 copper layers, 110.5 x 11.4 mm, 21 parts (0 on the bottom side), 10 nets.

## KiCad design narra 0805design/narra 0805design.kicad_pcb

Schematic: narra 0805design.sch

Parts:
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_0805
J1: P1_rows; Measurement_Point_Square-SMD-Pad_Small
J2: P2_columns; Measurement_Point_Square-SMD-Pad_Small
R1, R2, R3, R4, R5, R6, R7, R8: 37; R_0805

Connections:
/C: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), J2.1
GNDREF: J1.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R5.1
unnamed: D6.1 (K), R6.1
unnamed: D7.1 (K), R7.1
unnamed: D8.1 (K), R8.1

Board: 2 copper layers, 61.0 x 11.7 mm, 18 parts (0 on the bottom side), 10 nets.

## KiCad design narra.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8: LED_RGB; LED_WS2812-PLCC6

Connections:
/Columns_anode: D1.4 (BA), D1.5 (GA), D1.6 (RA), D2.4 (BA), D2.5 (GA), D2.6 (RA), D3.4 (BA), D3.5 (GA), D4.4 (BA), D4.5 (GA), D4.6 (RA), D5.4 (BA), D5.5 (GA), D5.6 (RA), D6.4 (BA), D6.5 (GA), D6.6 (RA), D7.4 (BA), D7.5 (GA), D7.6 (RA), D8.4 (BA), D8.5 (GA), D8.6 (RA)
/Rows_cathode: D1.1 (RK), D1.2 (GK), D1.3 (BK), D2.1 (RK), D2.2 (GK), D2.3 (BK), D3.1 (RK), D3.2 (GK), D3.3 (BK), D4.1 (RK), D4.2 (GK), D4.3 (BK), D5.1 (RK), D5.2 (GK), D5.3 (BK), D6.1 (RK), D6.2 (GK), D6.3 (BK), D7.2 (GK), D7.3 (BK), D8.1 (RK), D8.2 (GK), D8.3 (BK)

Board: 2 copper layers, 8 parts (0 on the bottom side), 2 nets, no tracks yet.

## Commit log (part)

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2017-03-17 Add first javascript template
2017-03-30 Changed the schematic to use compatible SMD LED components
2017-03-31 Re-organized the narra repo to incorporate the new designs: LED5050 and LED0805 designs
2017-04-03 Changed SMD resistor footprint to through-hole type.
2017-04-03 Add 3D image of design using the Kicad POV renderer0
2017-04-03 Move PCB dimensions to dwgs.user layer
2017-04-04 Correct PCB file for appropriate parsing in kicad
2017-04-06 Move ND-01 design into separate folder
2017-04-06 complete preliminary ND01 system
2017-04-09 Add row control test results
2017-04-11 Add separate driver uses to schematic
2017-04-11 Add protection resistors to external row driver connector
2017-04-20 Regenerated gerber files to register the required corrections for the PCB manufacturer.
2017-04-22 semicomplete design
2017-04-24 Move design files to hardware folder
2017-04-24 Add trademark file
2017-04-24 Add images and rename test-results folder
2017-04-24 Change markdown formatting
2017-04-24 Add gerbers
2017-04-24 Modify documentation readme file
2017-04-24 modify readme image
2017-04-24 modify readme.md
2017-05-29 Add cross compilation build folder
2017-06-28 complete Bitsoko ESP32 module design
2017-07-06 Add matrix control files
2017-07-06 Correct variable name
2017-07-07 Refactor matrix code
2017-07-09 Minor syntax changes
2017-08-08 Add UTF-8 decode and display support
2017-08-10 Correct pointer notation ======================== 1. Correct pointer notation as at https://esp32.com/viewtopic.php?f=13&t=2684 . 2.Prevent reading out of bounds on the utf8string. 3.Remove delay at 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
2017-08-12 Implement system loader ======================= 1.Implemented a system loader that loads system variables from flash.It should write default variables to nvs-flash for first time use. 2.The system lo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
2017-08-12 Add API that moves the matrix controller from one mode to another ================================================================= 1. The different APIs are startup, active and shutdown. 2. The reco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
2017-08-15 Finalise API ============ Check for bug that disbles showing of the shutdown message.
2017-08-15 Make compilational directive more readable
2017-08-17 minor changes before sitching branch
2017-08-17 Replaced pin headers with offset staggered headers from a friction fit without soldering
2017-08-18 complete ESP32 programmer design
2017-08-18 Add ESP32 module STEP file
2017-08-19 Semi-finalise Narra driver design ================================= 1. Rememeber to add resistors for row current limiting. 2. Remember to add button space for testing bluetooth.
2017-08-19 Eliminate explicit calls to printf in component source code =========================================================== 1. Eliminated the above and macros to control the inclusion of print utilities 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
2017-08-20 Include missing terminal block in driver layout
2017-08-20 Add Company logo and designer signature in module layout design
2017-08-20 rename bluetooth component folder to BLE
2017-08-21 Changed Bitsoko ESP32 footprint to component binding in CVPCB.
    Reason is detailed in commit d994a4fa
2017-08-21 Change module in ESP32 programmer
2017-08-28 Add BLE resources directory for future reference
2017-08-29 Design rule chcker pass
    1.DRC pass for ESP32 module and no unconnected nets.
    2.DRC pass for ESP32 programmer and no unconnected nets.
2017-08-29 Add contributors list file
    1. Reduced content in readme file by splitting off contributors list to a separate file.
2017-08-29 Add mounting holes
2017-08-29 Correct ESP-32 design based on tests
    1. TXD of the ESP32 was connected to TXD of the FTDI programmer. This was corrected RXD<=>TXD and vice versa.
    2. The DTR programmer line was connected to the EN line of the ESP32. This allows use of the DIP switch or tactile button to set boot mode.
2017-08-29 Add ND-03 gerbers folder and zip
2017-08-29 Add Kicad gerber generation settings reference for 2 layer and 4 layer boards
2017-09-01 Set pad-mask clearance to 5mils on ESP32 module
    1. This will allow the WROOM32 module to sit squarely on the PCB on the designated pads prior to soldering.
    2. TODO: This has not been updated on the gerbers as at this time.
2017-09-01 Rename contributors file
2017-09-03 Add python bluetooth address/mac checker utility
    1. The script needs a connected esp32.
    2. The device address is calculated based on sdkconfig settings and the base mac queried from the connected chip EFUSE.
2017-09-03 Minor code modification. No impact on output
2017-09-03 Add exit codes to python script
2017-09-03 Refactor script and correct local readme file
2017-09-04 Remove expressions using sring strip mehods
    Such methods used had little/no impact in the code after inspection.
2017-09-04 Eliminate whitespace in returned Bluetooth address
2017-09-10 Eliminate non changing system variables in system_parameters struct
    1. Remove double pin initialisation in system parameters and the matrix structure entity.
    2. Delegated this task to the matrix struct entity.
    3. The system variable struct shall only be for variables of interest changeable during runtime.
2017-09-11 Add rapid prototyping files
    1.ND-03_Stand_frame.dxf is useful for laser cutting a frame that one can use as a 2D-reference for drilling on a material to get the screw holes right.
    2.ND-03_drill_holes.dxf is useful for visualisation on a material to see where to place the holes. Is also useful to laser cut holes instead of the (1) above.
    3.ND-03_single_standoff.dxf is useful for placing standoffs under the driver board to prevent unwanted electrical contact. It is I deally useful to be lasser cut from acrylic/perspex. The user can th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
    4.STEP file for 3D visualisation, The contents of the STEP file are d
2017-09-12 Rearrange doc/Useful_info/ directory
2017-09-13 Delete esp32 original module with on board programmer
    1. It was much better making our own programmer from scratch, which is incorporated in version 2.
2017-09-14 Initialise structure pointer members to NULL
    1. This avoids leaving it to the compiler to initialise the structure pointer members.
    2. Allows working with the pointers from a defined state from point of definition.
2017-09-14 Add check for message pointer initialisation
    1. This allows one to free pointer memory if already initialised.
    2. Related to previous commit #12e1fe57
2017-09-14 Add member handle in prep write structure
    1. Enables the buffer to have an associated attribute handle and checking this at exec_write.
    2. This enables associating the buffer handle to the attribute handle table.
    3. ESP-IDF have not implemented a handle associated with an exec_write member in the callback parameter union as per 3.0-dev.
2017-09-14 Add system_loader call within the update functions
    1. This allows the loader to do a live update of system parameters on update, without waiting on reboot.
    2. This does not apply to the system_state updater as the state is volatile. No commit of system state to NVS on update.
2017-09-15 Remove the structure from within the display task for data integrity
    1. Allows the structure to be global thus is not stored on the stack frame.
2017-09-16 Successfully fused display task and BLE task
    1. Bug: BLE task is not feeding the task watchdog, find out where it is not exiting. Most likely a pointer issue.
    2. Bug: The reads from the state attribute are showing 0x02 where it is meant to be 0x01.
    3. TODO: Test the signals on an oscilloscope to see that the pins are being drivem from the display task..
2017-09-17 Refactor prepare write function in ble.c
    1. Created prepare buffer function for the purposes of allocating the buffer size and sending a response.
    2. Enables code maintainability as the project matures.
2017-09-17 Fix bug stated in commit a6760f0f9be128b5b83c1a792a3e0258c5e1e8aa
    1. Fixed missing array element separator(comma).
2017-09-17 Modify the nara_state_enum datatype values to make them more logical.
    1. Set shutdown as 0x00, active 0x01, startup 0x02.
    2. This would allow more logical code when working with raw values.
    3. Example: matrix_change_state(val), where 0 is shutdown, 1 is active.
2017-09-17 Call updater after string validity verification
    1. This commits the new text to NVS flash but does not load it.
    2. Loading should be done by the loader after an update has occured and the renderer has completed.
2017-09-18 Correct syntax errors
2017-09-18 Adopt consistent naming scheme for firmware library folders
    1. External libraries shall also now be kept in one folder.
    2. The libraries made for this project shall have the suffix "_api".
2017-09-18 Add debug logging calls
    1. Allows to visually see which function has been called.
    2. TODO: The BLE advert takes too long to start. The scrolling happens first. Try to see why.
2017-09-18 Add header guards to ble_config.h
    1. Use: Defensive! Prevents multiple inclusion.
2017-09-18 Add ability to obtain BASE_MAC by script
    1. Added a pretty function that obtains the base MAC in the needed format. Example: "24-ac-0a-4a-56-2f"
2017-09-18 Correct config_ble.h source code flow
    1. Previous formatting had use before definition/declaration.
    2. Correct device address to have the correct chip ble id. This should be automated by script.
2017-09-18 wrap print function parameter with parenthesis.
    1. Ensures the script is compatible with both python 2.7 and python 3.5 as tested on system.
2017-09-20 Add text updater functionality 1. This will allow the various texts to be updateable over BLE. 2. The update mechanism is immediate but the text is visually updated at the next scroll. 3. This is bec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
2017-09-20 Move the bit definitions for the event group to narra_defines
    1. Allows the defines to be accessible at a common project file so that the various definitions do not pop up.
2017-09-26 Fix update shutdown string bug for short writes
    1. The shutdown string handler was not being checked for short writes. Updated handler check.
2017-09-26 Update contributors file
2017-09-26 Switch from a "counting UTF8" check to a "simple UTF8" check
    This would allow just checking the string for UTF8 validity instead of counting the UTF8 chars also, probably in future this may be useful.
2017-09-27 Add break in switch case. Fix identation!
2017-09-27 Several commits in this commit 1. Changed how function entrance debug messages are printed. Added square brackets around func name. 2. Added a soft check that checks the controller state in the matri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
2017-09-28 Changed device infomation service characteristics' string format
    1. The manufacturer name string and firmware version string are now as strings defined as macros. This is in contrast to the previous way where the string values were defined as hexadecimal values in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
    2. This was done to allow the values to be changed at compile time via a python script especially the firmware version by reading the git tag and current commit number.
2017-09-28 Change generic access service device name
    1. The device name in SIG defined service generic access shall now hold the product name. In this case it is narra.
    2. This allows the connecting software to the gatt server to query the product name if it is so needed in future.
2017-09-29 Add LOGI messages to show truncation during reads
2017-10-01 Remove matrix reboot feature
    1. Feature is unneedded and is only useful if explicitely requested.
2017-10-02 Patched ble configurations
    1. Set man name to "BITSOKO_SERVICES"
    2. Manually changed the firmware rev to v0.9.2 to simulate that the python script did this.
2017-10-07 Update licence on source files
2017-11-05 Change pin to board mapping
    1. Swapped the pins row_reset and row_clock to match the ND-03 board design.
2017-11-05 Modify build file
    1. Change the toolchain version. The correct is obtained via readthedocs for v2.1 of esp-idf
2017-11-11 Make advertised URL more readable
2017-11-15 Add licence to main file
2017-12-02 Prepare release version
2017-12-02 Finalise documentation in README
2017-12-02 Add minor readme documentation on communication stack
2017-12-09 Bump up version string
    Bump up string to release version 1.0
