# Repository Kiogora/narra

File README.md:

## Narra - An LED Signage Development Project

This repository contains hardware designs and software for Narra, an open source, BLE advertising and control, LED signage platform. The project utilises the ESP32 and the ESP-IDF framework. The signage device had to be able to be controlled over BLE via a mobile connection with web bluetooth running on the client web browser that would control the signage device functions such as what to display and change the device state by writing to predefined BLE characteristics.

This repository is Bluetooth v4.2 compliant.

### Hardware

The hardware is made with the open-source PCB design tool [Kicad](http://kicad-pcb.org/). The hardware designs include:

1. A custom programmer that made using a common commercial off the shelf CP210x UART-USB converter.
2. The LED driver board as at different versions.
3. A custom ESP32 module, friendly for development and product placement made from the ESP WROOM32. It is meant to be programmed using the programmer above.

### Firmware

The fimware is divided into different components that are abstracted from each other and written in Pure C utilising the ESP-IDF framework and include:

#### Communication stack:

1. ble_api- Contains utilities to control the BLE hardware. Interacts directly with the ESP BLE HAL. It is strictly written with multiple level of sanity checks on the input data from user prior to writing to flash.

#### Other components:

2. common_api-Contains constants and definitions that persist across source files.

3. controller_api- Contains the abstraction layer that enables/disables the display as well as verification that the text as UTF-8.

4. external_libs- External libraries that are used. The one currently used is a modified version of the utf_8 decoder library by Bjoern Hoehrman.

5. loader_api- API that is used to load from flash newly written variables via BLE. This is done at boot and after update via BLE dynamically.

6. updater_api- API that is used to update the system variables in flash.

7. renderer_api- This is the API that is heavily tied to the hardware itself and display method. The current display method is a row-scan method that takes advantage of the human persistence of vision.It also includes a header file containg the implemented character glyphs.

7. main file- Is used to setup the various tasks and coordinates the various task interactions.

The communication stack is meant to be purely independent of other components thus one could use a TCP/IP or cellular stack and just reuse the same interface and function calls or add to them.

### Building and uploading the code to device

Setup development environment using the build script in the utils/build folder:

```shell
cd utils/build
sh setup.sh
```
Now build the firmware and flash to device over UART:
```shell
cd ../../../firmware
make flash
``` 

The firmware is build for extensibility to support new codepoints under UTF-8. 

To add new characters, one just has to:

1. create the glyphs that represent the characters for that language and add to the existing in renderer_api/include/glyphmap.h . The characters are defined in codepoint ranges. To add a single character, the character range is 1.

2. Change the allowed character UTF-8 codepoint ranges in  common_api/narra_defines "UTF-8 implementation defines" section and add your own following the UTF-8 encoding ranges.

3. Add the checks for the new codepoint definitions, added above, in the renderer so that your new implementation is recognised. 

### Contributors

[Alois Mbutura](https://alois.live/) "aloismbutura@gmail.com"

Felix omwansa "omwansafelixa@gmail.com"

See CONTRIBUTORS file

## KiCad design hardware/ESP-32-programmer/ESP-32-programmer.kicad_pcb

File hardware/README.md:

## Narra - An LED Signage Development Project

### Hardware

Parts:
C1, C2: 10uF; CP_Radial_D5.0mm_P2.50mm
D1: LED; LED_D3.0mm
J1, J7, J8: GS2
J2, J6: CONN_01X06; Pin_header_5mil_staggered_1x06_2.54mm
J3, J4, J5: CONN_02X10; Pin_Header_Straight_2x10_Pitch2.54mm_staggered
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R3: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_DIP_x02; SW_DIP_x2_W7.62mm_Slide_LowProfile
SW2: SW_Push; SW_PUSH_SMALL
U1: LD1117S33TR_SOT223; TO-220_Neutral123_Vertical_LargePads
U2: ESP-32-module; ESP32-module-v2

Connections:
/3v3: C2.1, J2.4, J5.2, J7.2 (G2), J8.2 (G2), R2.1, R3.1, U1.2 (VO), U2.2 (3V3)
/5v: C1.1, D1.2 (A), J4.1, J4.2, J6.1, U1.3 (VI)
/CLK: J5.20, U2.20 (CLK)
/CMD: J5.19, U2.19 (CMD)
/DTR: J1.2 (G2), J2.1, J5.3, J6.5, R2.2, U2.3 (EN)
/IO0: J4.15, R3.2, SW1.1, SW1.2, SW2.1, U2.34 (IO0)
/IO2: J4.18, U2.35 (IO2)
/IO4: J4.16, U2.33 (IO4)
/IO5: J4.11, U2.30 (IO5)
/IO16: J4.13, U2.32 (IO16)
/IO17: J4.14, U2.31 (IO17)
/IO18: J4.12, U2.29 (IO18)
/IO19: J4.9, U2.28 (IO19)
/IO20: J4.10, U2.27 (IO20)
/IO21: J4.7, U2.26 (IO21)
/IO22: J4.6, U2.23 (IO22)
/IO23: J4.3, U2.22 (IO23)
/IO25: J5.10, U2.10 (IO25)
/IO26: J5.11, U2.11 (IO26)
/IO27: J5.12, U2.12 (IO27)
/IO32: J5.8, U2.8 (IO32)
/IO33: J5.9, U2.9 (IO33)
/IO34: J5.6, U2.6 (IO34)
/IO35: J5.7, U2.7 (IO35)
/RXD: J2.2, J4.8, J6.4, U2.24 (TXD)
/SD0: J4.19, U2.38 (SD0)
/SD1: J4.20, U2.37 (SD1)
/SD2: J5.17, U2.17 (SD2)
/SD3: J5.18, U2.18 (SD3)
/SVN: J5.5, U2.5 (SVN)
/SVP: J5.4, U2.4 (SVP)
/TCK: J3.9, J5.16, U2.16 (IO13)
/TDI: J3.5, J5.14, U2.14 (IO12)
/TDO: J3.13, J4.17, U2.36 (IO15)
/TMS: J3.7, J5.13, U2.13 (IO14)
/TXD: J2.3, J4.5, J6.3, U2.25 (RXD)
/~TRST: J1.1 (G1), J3.3
GND: C1.2, C2.2, J2.6, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J3.16, J3.18, J3.20, J4.4, J5.1, J5.15, J6.2, R1.2, SW1.3, SW1.4, SW2.2, U1.1 (GND), U2.1 (GND), U2.15 (GND), U2.21 (GND)
unnamed: D1.1 (K), R1.1
unnamed: J3.1, J7.1 (G1)
unnamed: J6.6, J8.1 (G1)

Notes on the sheet:
SPARKFUN FTDI INTERFACE
POWER CONVERSION
JTAG INTERFACE
CONNECTOR A
ESP32 MODULE
CONNECTOR B
CP2102 interface
Reference: 1. https://visualgdb.com/tutorials/esp32/ 2. http://tiaowiki.com/w/TIAO_USB_Multi_Protocol_Adapter_Lite_User%27s_Manual
SYSTEM_RESET
BOOT MODE SELECTION(PU-SPI BOOT, PD-DOWNLOAD BOOT)

Board: 2 copper layers, 100.0 x 45.0 mm, 18 parts (1 on the bottom side), 41 nets.

## KiCad design hardware/Bitsoko-ESP32-module-v2/Bitsoko-ESP32-module-v2.kicad_pcb

File hardware/README:

# Narra - An LED Signage Development Project

##Hardware

Parts:
C1, C3: 0.1uF; C_0805_HandSoldering
C2: 22uF; C_1210_HandSoldering
J1, J2: CONN_02X10; Pin_Header_Straight_2x10_Pitch2.54mm_8mil_staggered
U1: ESP32-WROOM32-MODULE; ESP-WROOM32-MODULE

Connections:
/3V3: C1.1, C2.1, J2.2, U1.2 (3v3)
/CLK: J2.20, U1.20 (CLK)
/CMD: J2.19, U1.19 (CMD)
/EN: C3.1, J2.3, U1.3 (EN)
/IO0: J1.13, U1.25 (GPIO0)
/IO2: J1.16, U1.24 (GPIO2)
/IO4: J1.14, U1.26 (GPIO4)
/IO5: J1.9, U1.29 (GPIO5)
/IO12: J2.14, U1.14 (GPIO12)
/IO13: J2.16, U1.16 (GPIO13)
/IO14: J2.13, U1.13 (GPIO14)
/IO15: J1.15, U1.23 (GPIO15)
/IO16: J1.11, U1.27 (GPIO16)
/IO17: J1.12, U1.28 (GPIO17)
/IO18: J1.10, U1.30 (GPIO18)
/IO19: J1.7, U1.31 (GPIO19)
/IO20: J1.8, U1.32 (GPIO20)
/IO21: J1.5, U1.33 (GPIO21)
/IO22: J1.4, U1.36 (GPIO22)
/IO23: J1.1, U1.37 (GPIO23)
/IO25: J2.10, U1.10 (GPIO25)
/IO26: J2.11, U1.11 (GPIO26)
/IO27: J2.12, U1.12 (GPIO27)
/IO32: J2.8, U1.8 (GPIO32)
/IO33: J2.9, U1.9 (GPIO33)
/IO34: J2.6, U1.6 (GPIO34)
/IO35: J2.7, U1.7 (GPIO35)
/RXD: J1.6, U1.34 (RXD0)
/SD0: J1.17, U1.21 (SD0)
/SD1: J1.18, U1.22 (SD1)
/SD2: J2.17, U1.17 (SD2)
/SD3: J2.18, U1.18 (SD3)
/SVN: J2.5, U1.5 (sensorVN)
/SVP: J2.4, U1.4 (sensorVP)
/TXD: J1.3, U1.35 (TXD0)
GND: C1.2, C2.2, C3.2, J1.2, J2.1, J2.15, U1.1 (GND1), U1.15 (GND2), U1.38 (GND3)

Notes on the sheet:
Power decoupling
Rise time control EN pin

Board: 2 copper layers, 40.6 x 27.9 mm, 6 parts (3 on the bottom side), 36 nets.

## KiCad design hardware/drivers/ND-03/ND-03.kicad_pcb

Board: 4 copper layers, 155.6 x 134.7 mm, 126 parts (0 on the bottom side), 181 nets.

Parts:
C1, C2: 10uF; CP_Radial_D5.0mm_P2.50mm
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18: 10nF; C_Disc_D3.4mm_W2.1mm_P2.50mm
D1: LED; LED_D5.0mm
D2: D_Zener; D_T-1_P5.08mm_Horizontal
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31, J32, J33, J34, J35, J36, J37, J38, J39, J40, J41, J42, J43, J44, J45, J46, J47, J48, J49, J50, J51, J52, J53, J54, J55, J56, J57, J58, J59, J60, J61, J62, J63, J64, J65, J66, J67, J69, J70, J71, J72: Screw_Terminal_1x02; TerminalBlock_Pheonix_MKDS1.5-2pol
J68: GS3
J73, J74: GS2
Q1: Q_PMOS_GDS; TO-220_Neutral123_Vertical_LargePads
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R3, R4, R5, R6, R7, R8, R9: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: ESP-32-module; ESP32-module-v2
U2: LD1117S33TR_SOT223; TO-220_Neutral123_Vertical
U3: LM2596_MODULE
U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19: 74HC595; DIP-16_W7.62mm_LongPads
U20: ULN2803A; DIP-18_W7.62mm_LongPads
U21: CD4017; DIP-16_W7.62mm_Socket_LongPads

Connections:
3v3: C1.1, U1.2, U2.2
5v: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, D1.2, D2.1, J73.1, J74.1, Q1.3, U2.3, U4.10, U4.16, U5.10, U5.16, U6.10, U6.16, U7.10, U7.16, U8.10, U8.16, U9.10, U9.16, U10.10, U10.16, U11.10, U11.16, U12.10, U12.16, U13.10, U13.16, U14.10, U14.16, U15.10, U15.16, U16.10, U16.16, U17.10, U17.16, U18.10, U18.16, U19.10, U19.16, U21.16
/CLK: U1.13, U21.14
/DATA: U1.10, U4.14
/INPUT_5V: J1.1, J2.1, J73.2, J74.2, Q1.2, U3.3
/LATCH: U1.12, U4.12, U5.12, U6.12, U7.12, U8.12, U9.12, U10.12, U11.12, U12.12, U13.12, U14.12, U15.12, U16.12, U17.12, U18.12, U19.12
/RESET: U1.14, U21.15
/SHIFT: U1.11, U4.11, U5.11, U6.11, U7.11, U8.11, U9.11, U10.11, U11.11, U12.11, U13.11, U14.11, U15.11, U16.11, U17.11, U18.11, U19.11
/Sheet599728AA/JUMP: J68.2, U20.8
/Sheet599728AA/Q0: J68.1, U21.3
/Sheet599728AA/Q1: U20.7, U21.2
/Sheet599728AA/Q2: U20.6, U21.4
/Sheet599728AA/Q3: U20.5, U21.7
/Sheet599728AA/Q4: U20.4, U21.10
/Sheet599728AA/Q5: U20.3, U21.1
/Sheet599728AA/Q6: U20.2, U21.5
/Sheet599728AA/Q7: U20.1, U21.6
/Sheet599728AA/Q8: J68.3, U21.9
/Sheet599728AA/R1: J72.1, R2.2
/Sheet599728AA/R2: J72.2, R3.2
/Sheet599728AA/R3: J71.1, R4.2
/Sheet599728AA/R4: J71.2, R5.2
/Sheet599728AA/R5: J69.1, R6.2
/Sheet599728AA/R6: J69.2, R7.2
/Sheet599728AA/R7: J70.1, R8.2
/Sheet599728AA/R8: J70.2, R9.2
/Sheet59972800/Sheet59973A04/C1: J58.1, U16.15
/Sheet59972800/Sheet59973A04/C2: J58.2, U16.1
/Sheet59972800/Sheet59973A04/C3: J59.1, U16.2
/Sheet59972800/Sheet59973A04/C4: J59.2, U16.3
/Sheet59972800/Sheet59973A04/C5: J60.1, U16.4
/Sheet59972800/Sheet59973A04/C6: J60.2, U16.5
/Sheet59972800/Sheet59973A04/C7: J61.1, U16.6
/Sheet59972800/Sheet59973A04/C8: J61.2, U16.7
/Sheet59972800/Sheet59973A04/C9: J62.1, U17.15
/Sheet59972800/Sheet59973A04/C10: J62.2, U17.1
/Sheet59972800/Sheet59973A04/C11: J63.1, U17.2
/Sheet59972800/Sheet59973A04/C12: J63.2, U17.3
/Sheet59972800/Sheet59973A04/C13: J55.1, U17.4
/Sheet59972800/Sheet59973A04/C14: J55.2, U17.5
/Sheet59972800/Sheet59973A04/C15: J56.1, U17.6
/Sheet59972800/Sheet59973A04/C16: J56.2, U17.7
/Sheet59972800/Sheet59973A04/C17: J52.1, U18.15
/Sheet59972800/Sheet59973A04/C18: J52.2, U18.1
/Sheet59972800/Sheet59973A04/C19: J53.1, U18.2
/Sheet59972800/Sheet59973A04/C20: J53.2, U18.3
/Sheet59972800/Sheet59973A04/C21: J54.1, U18.4
/Sheet59972800/Sheet59973A04/C22: J54.2, U18.5
/Sheet59972800/Sheet59973A04/C23: J57.1, U18.6
/Sheet59972800/Sheet59973A04/C24: J57.2, U18.7
/Sheet59972800/Sheet59973A04/C25: J64.1, U19.15
/Sheet59972800/Sheet59973A04/C26: J64.2, U19.1
/Sheet59972800/Sheet59973A04/C27: J65.1, U19.2
/Sheet59972800/Sheet59973A04/C28: J65.2, U19.3
/Sheet59972800/Sheet59973A04/C29: J66.1, U19.4
/Sheet59972800/Sheet59973A04/C30: J66.2, U19.5
/Sheet59972800/Sheet59973A04/C31: J67.1, U19.6
/Sheet59972800/Sheet59973A04/C32: J67.2, U19.7
/Sheet59972800/Sheet59973A04/DATA: U11.9, U16.14
/Sheet59972800/Sheet59973A04/SER_1: U16.9, U17.14
/Sheet59972800/Sheet59973A04/SER_2: U17.9, U18.14
/Sheet59972800/Sheet59973A04/SER_3: U18.9, U19.14
/Sheet59972800/Sheet599739F6/C1: J10.1, U4.15
/Sheet59972800/Sheet599739F6/C2: J10.2, U4.1
/Sheet59972800/Sheet599739F6/C3: J11.1, U4.2
/Sheet59972800/Sheet599739F6/C4: J11.2, U4.3
/Sheet59972800/Sheet599739F6/C5: J12.1, U4.4
/Sheet59972800/Sheet599739F6/C6: J12.2, U4.5
/Sheet59972800/Sheet599739F6/C7: J13.1, U4.6
/Sheet59972800/Sheet599739F6/C8: J13.2, U4.7
/Sheet59972800/Sheet599739F6/C9: J14.1, U5.15
/Sheet59972800/Sheet599739F6/C10: J14.2, U5.1
/Sheet59972800/Sheet599739F6/C11: J15.1, U5.2
/Sheet59972800/Sheet599739F6/C12: J15.2, U5.3
/Sheet59972800/Sheet599739F6/C13: J7.1, U5.4
/Sheet59972800/Sheet599739F6/C14: J7.2, U5.5
/Sheet59972800/Sheet599739F6/C15: J8.1, U5.6
/Sheet59972800/Sheet599739F6/C16: J8.2, U5.7
/Sheet59972800/Sheet599739F6/C17: J4.1, U6.15
/Sheet59972800/Sheet599739F6/C18: J4.2, U6.1
/Sheet59972800/Sheet599739F6/C19: J5.1, U6.2
/Sheet59972800/Sheet599739F6/C20: J5.2, U6.3
/Sheet59972800/Sheet599739F6/C21: J6.1, U6.4
/Sheet59972800/Sheet599739F6/C22: J6.2, U6.5
/Sheet59972800/Sheet599739F6/C23: J9.1, U6.6
/Sheet59972800/Sheet599739F6/C24: J9.2, U6.7
/Sheet59972800/Sheet599739F6/C25: J16.1, U7.15
/Sheet59972800/Sheet599739F6/C26: J16.2, U7.1
/Sheet59972800/Sheet599739F6/C27: J17.1, U7.2
/Sheet59972800/Sheet599739F6/C28: J17.2, U7.3
/Sheet59972800/Sheet599739F6/C29: J18.1, U7.4
/Sheet59972800/Sheet599739F6/C30: J18.2, U7.5
/Sheet59972800/Sheet599739F6/C31: J19.1, U7.6
/Sheet59972800/Sheet599739F6/C32: J19.2, U7.7
/Sheet59972800/Sheet599739F6/SER_1: U4.9, U5.14
/Sheet59972800/Sheet599739F6/SER_2: U5.9, U6.14
/Sheet59972800/Sheet599739F6/SER_3: U6.9, U7.14
/Sheet59972800/Sheet599739F9/C1: J26.1, U8.15
/Sheet59972800/Sheet599739F9/C2: J26.2, U8.1
/Sheet59972800/Sheet599739F9/C3: J27.1, U8.2
/Sheet59972800/Sheet599739F9/C4: J27.2, U8.3
/Sheet59972800/Sheet599739F9/C5: J28.1, U8.4
/Sheet59972800/Sheet599739F9/C6: J28.2, U8.5
/Sheet59972800/Sheet599739F9/C7: J29.1, U8.6
/Sheet59972800/Sheet599739F9/C8: J29.2, U8.7
/Sheet59972800/Sheet599739F9/C9: J30.1, U9.15
/Sheet59972800/Sheet599739F9/C10: J30.2, U9.1
/Sheet59972800/Sheet599739F9/C11: J31.1, U9.2
/Sheet59972800/Sheet599739F9/C12: J31.2, U9.3
/Sheet59972800/Sheet599739F9/C13: J23.1, U9.4
/Sheet59972800/Sheet599739F9/C14: J23.2, U9.5
/Sheet59972800/Sheet599739F9/C15: J24.1, U9.6
/Sheet59972800/Sheet599739F9/C16: J24.2, U9.7
/Sheet59972800/Sheet599739F9/C17: J20.1, U10.15
/Sheet59972800/Sheet599739F9/C18: J20.2, U10.1
/Sheet59972800/Sheet599739F9/C19: J21.1, U10.2
/Sheet59972800/Sheet599739F9/C20: J21.2, U10.3
/Sheet59972800/Sheet599739F9/C21: J22.1, U10.4
/Sheet59972800/Sheet599739F9/C22: J22.2, U10.5
/Sheet59972800/Sheet599739F9/C23: J25.1, U10.6
/Sheet59972800/Sheet599739F9/C24: J25.2, U10.7
/Sheet59972800/Sheet599739F9/C25: J32.1, U11.15
/Sheet59972800/Sheet599739F9/C26: J32.2, U11.1
/Sheet59972800/Sheet599739F9/C27: J33.1, U11.2
/Sheet59972800/Sheet599739F9/C28: J33.2, U11.3
/Sheet59972800/Sheet599739F9/C29: J34.1, U11.4
/Sheet59972800/Sheet599739F9/C30: J34.2, U11.5
/Sheet59972800/Sheet599739F9/C31: J35.1, U11.6
/Sheet59972800/Sheet599739F9/C32: J35.2, U11.7
/Sheet59972800/Sheet599739F9/DATA: U7.9, U8.14
/Sheet59972800/Sheet599739F9/SER_1: U8.9, U9.14
/Sheet59972800/Sheet599739F9/SER_2: U9.9, U10.14
/Sheet59972800/Sheet599739F9/SER_3: U10.9, U11.14
/Sheet59972800/Sheet599739FF/C1: J42.1, U12.15
/Sheet59972800/Sheet599739FF/C2: J42.2, U12.1
/Sheet59972800/Sheet599739FF/C3: J43.1, U12.2
/Sheet59972800/Sheet599739FF/C4: J43.2, U12.3
/Sheet59972800/Sheet599739FF/C5: J44.1, U12.4
/Sheet59972800/Sheet599739FF/C6: J44.2, U12.5
/Sheet59972800/Sheet599739FF/C7: J45.1, U12.6
/Sheet59972800/Sheet599739FF/C8: J45.2, U12.7
/Sheet59972800/Sheet599739FF/C9: J46.1, U13.15
/Sheet59972800/Sheet599739FF/C10: J46.2, U13.1
/Sheet59972800/Sheet599739FF/C11: J47.1, U13.2
/Sheet59972800/Sheet599739FF/C12: J47.2, U13.3
/Sheet59972800/Sheet599739FF/C13: J39.1, U13.4
/Sheet59972800/Sheet599739FF/C14: J39.2, U13.5
/Sheet59972800/Sheet599739FF/C15: J40.1, U13.6
/Sheet59972800/Sheet599739FF/C16: J40.2, U13.7
/Sheet59972800/Sheet599739FF/C17: J36.1, U14.15
/Sheet59972800/Sheet599739FF/C18: J36.2, U14.1
/Sheet59972800/Sheet599739FF/C19: J37.1, U14.2
/Sheet59972800/Sheet599739FF/C20: J37.2, U14.3
/Sheet59972800/Sheet599739FF/C21: J38.1, U14.4
/Sheet59972800/Sheet599739FF/C22: J38.2, U14.5
/Sheet59972800/Sheet599739FF/C23: J41.1, U14.6
/Sheet59972800/Sheet599739FF/C24: J41.2, U14.7
/Sheet59972800/Sheet599739FF/C25: J48.1, U15.15
/Sheet59972800/Sheet599739FF/C26: J48.2, U15.1
/Sheet59972800/Sheet599739FF/C27: J49.1, U15.2
/Sheet59972800/Sheet599739FF/C28: J49.2, U15.3
/Sheet59972800/Sheet599739FF/C29: J50.1, U15.4
/Sheet59972800/Sheet599739FF/C30: J50.2, U15.5
/Sheet59972800/Sheet599739FF/C31: J51.1, U15.6
/Sheet59972800/Sheet599739FF/C32: J51.2, U15.7
/Sheet59972800/Sheet599739FF/DATA: U12.14, U19.9
/Sheet59972800/Sheet599739FF/SER_1: U12.9, U13.14
/Sheet59972800/Sheet599739FF/SER_2: U13.9, U14.14
/Sheet59972800/Sheet599739FF/SER_3: U14.9, U15.14
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, J1.2, J2.2, J3.2, R1.2, R10.2, U1.1, U1.15, U1.21, U2.1, U3.2, U3.4, U4.8, U4.13, U5.8, U5.13, U6.8, U6.13, U7.8, U7.13, U8.8, U8.13, U9.8, U9.13, U10.8, U10.13, U11.8, U11.13, U12.8, U12.13, U13.8, U13.13, U14.8, U14.13, U15.8, U15.13, U16.8, U16.13, U17.8, U17.13, U18.8, U18.13, U19.8, U19.13, U20.9, U21.8, U21.13
unnamed: D1.1, R1.1
unnamed: D2.2, Q1.1, R10.1
unnamed: J3.1, U3.1
unnamed: R2.1, U20.18
unnamed: R3.1, U20.17
unnamed: R4.1, U20.16
unnamed: R5.1, U20.15
unnamed: R6.1, U20.14
unnamed: R7.1, U20.13
unnamed: R8.1, U20.12
unnamed: R9.1, U20.11

## KiCad design hardware/Bitsoko-ESP32-module/Bitsoko-ESP32-module.kicad_pcb

Parts:
C1, C2: 10uF; C_0805_HandSoldering
D1: LED; LED_0805
R1: 1k; R_0805_HandSoldering
U1: NCP1117-3.3_SOT223; SOT-223

Connections:
3v3: C2.1, U1.2 (VO); also elsewhere on the board
/sheet59552648/EXT_5V: C1.1, D1.2 (A), U1.3 (VI); also elsewhere on the board
GND: C1.2, C2.2, R1.2, U1.1 (GND); also elsewhere on the board
unnamed: D1.1 (K), R1.1

Notes on the sheet:
3v3 Linear regulator

Parts:
J1: CONN_01X06; Pin_header_5mil_staggered_1x06_2.54mm

Connections:
3v3: J1.1; also elsewhere on the board
/sheet59552649/EN: J1.5; also elsewhere on the board
/sheet59552649/IO0: J1.4; also elsewhere on the board
/sheet59552649/RX: J1.2; also elsewhere on the board
/sheet59552649/TX: J1.3; also elsewhere on the board
GND: J1.6; also elsewhere on the board

Notes on the sheet:
Auto-programming ICSP UART header

Parts:
C3, C4: 1nF; C_0805_HandSoldering
C5: 10uF; C_0805_HandSoldering
C6: 0.1uF; C_0805_HandSoldering
R2, R3: 12k; R_0805_HandSoldering
R4: 5k; R_0805_HandSoldering
U2: ESP32-WROOM32-MODULE; ESP-WROOM32-MODULE

Connections:
3v3: C5.1, C6.1, R2.1, R3.1, U2.2 (3v3); also elsewhere on the board
/sheet5955264A/CLK: U2.20 (CLK); also elsewhere on the board
/sheet5955264A/CMD: U2.19 (CMD); also elsewhere on the board
/sheet5955264A/IO2: R4.1, U2.24 (GPIO2); also elsewhere on the board
/sheet5955264A/IO4: U2.26 (GPIO4); also elsewhere on the board
/sheet5955264A/IO5: U2.29 (GPIO5); also elsewhere on the board
/sheet5955264A/IO12: U2.14 (GPIO12); also elsewhere on the board
/sheet5955264A/IO13: U2.16 (GPIO13); also elsewhere on the board
/sheet5955264A/IO14: U2.13 (GPIO14); also elsewhere on the board
/sheet5955264A/IO15: U2.23 (GPIO15); also elsewhere on the board
/sheet5955264A/IO16: U2.27 (GPIO16); also elsewhere on the board
/sheet5955264A/IO17: U2.28 (GPIO17); also elsewhere on the board
/sheet5955264A/IO18: U2.30 (GPIO18); also elsewhere on the board
/sheet5955264A/IO19: U2.31 (GPIO19); also elsewhere on the board
/sheet5955264A/IO21: U2.33 (GPIO21); also elsewhere on the board
/sheet5955264A/IO22: U2.36 (GPIO22); also elsewhere on the board
/sheet5955264A/IO23: U2.37 (GPIO23); also elsewhere on the board
/sheet5955264A/IO25: U2.10 (GPIO25); also elsewhere on the board
/sheet5955264A/IO26: U2.11 (GPIO26); also elsewhere on the board
/sheet5955264A/IO27: U2.12 (GPIO27); also elsewhere on the board
/sheet5955264A/IO32: U2.8 (GPIO32); also elsewhere on the board
/sheet5955264A/IO33: U2.9 (GPIO33); also elsewhere on the board
/sheet5955264A/IO34: U2.6 (GPIO34); also elsewhere on the board
/sheet5955264A/IO35: U2.7 (GPIO35); also elsewhere on the board
/sheet5955264A/SD0: U2.21 (SD0); also elsewhere on the board
/sheet5955264A/SD1: U2.22 (SD1); also elsewhere on the board
/sheet5955264A/SD2: U2.17 (SD2); also elsewhere on the board
/sheet5955264A/SD3: U2.18 (SD3); also elsewhere on the board
/sheet5955264A/SENSOR_VN: U2.5 (sensorVN); also elsewhere on the board
/sheet5955264A/SENSOR_VP: U2.4 (sensorVP); also elsewhere on the board
/sheet59552649/EN: C3.1, R2.2, U2.3 (EN); also elsewhere on the board
/sheet59552649/IO0: C4.1, R3.2, U2.25 (GPIO0); also elsewhere on the board
/sheet59552649/RX: U2.34 (RXD0); also elsewhere on the board
/sheet59552649/TX: U2.35 (TXD0); also elsewhere on the board
GND: C3.2, C4.2, C5.2, C6.2, R4.2, U2.1 (GND1), U2.15 (GND2), U2.38 (GND3); also elsewhere on the board

Notes on the sheet:
Boot mode control IO0 1 Normal SPI flash boot control after reset 2. Download boot after reset
Reset control EN. 0 - Reset state 1 - Normal operation
Boot mode control IO2: 0 on download boot Dont care(X) on SPI boot
